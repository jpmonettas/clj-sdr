options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: udsio_uds_sink_0
  id: udsio_uds_sink
  parameters:
    socket_path: /tmp/clj_sdr.sock
    type: complex
    vlen: '1'
  states: {}
- name: udsio_uds_source_0
  id: udsio_uds_source
  parameters:
    socket_path: /tmp/clj_sdr.sock
    type: complex
    vlen: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', udsio_uds_sink_0, '0']
- [udsio_uds_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
